# Keil uVision project Ellipse.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ellipse
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4 __FPU_PRESENT
  c misc: --c99
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c ellipse_fitting.c ellipse_fitting_tests.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 2.1.0
